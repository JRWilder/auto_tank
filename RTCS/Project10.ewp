# IAR project Project10.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR2355 MSP430FR2355
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ./; C:\Users\Johnathan\OneDrive - North Carolina State University\auto_tank\RTCS\include; C:\Users\Johnathan\OneDrive - North Carolina State University\auto_tank\RTCS\src
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2355.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Compiled
    Compiled/: LCD.r43
  group include
    include/: ADC.h Calibration.h Functions.h Line_Follow.h Macros.h Ports.h PWM.h SERIAL_COM.h Timers.h WIFI_COM.h
  group src
    src/: Calibration.c Displays.c HEXtoBCD.c HEXtoBCD_Timer.c Init_ADC.c Init_Clocks.c Init_Conditions.c Init_Ports.c Init_SERIAL_COM.c Init_Timers.c ISR_ADC.c ISR_Ports.c ISR_Serial.c ISR_Timers.c Line_Follow.c Main.c PWM.c Reset.c SERIAL_COM.c system.c WIFI_COM.c
